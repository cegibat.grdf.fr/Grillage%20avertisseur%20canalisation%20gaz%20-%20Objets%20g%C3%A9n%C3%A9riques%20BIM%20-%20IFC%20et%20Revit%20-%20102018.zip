Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-10-18T17:31:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 18 17:31:05 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{BA315B35-3E5C-4188-94B3-D856F1039D3C}\ifc * Database version: 5507 * Database creation date: Thu Oct 18 17:31:03 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 18 17:31:03 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 18 17:31:03 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcBuildingElementProxy: Gaz naturel – Grillage avertisseur, Gaz naturel – Grillage avertisseur:Gaz naturel – Grillage avertisseur:207965
In: Niveau 1
Type - Material: JAUNE-2
Type - Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: Gaz naturel – Grillage avertisseur
Type - Données d'identification(Type) - Nom du type: Gaz naturel – Grillage avertisseur
Pset_BuildingElementProxyCommon - Reference: Gaz naturel – Grillage avertisseur
Autre - Catégorie: Modèles génériques; Famille: Gaz naturel – Grillage avertisseur: Gaz naturel – Grillage avertisseur; Famille et type: Gaz naturel – Grillage avertisseur: Gaz naturel – Grillage avertisseur; ID du type: Gaz naturel – Grillage avertisseur: Gaz naturel – Grillage avertisseur; Type: Gaz naturel – Grillage avertisseur: Gaz naturel – Grillage avertisseur
Contraintes - Décalage: 0 mm; Largeur: 300 mm; Lien vers les objets génériques BIM au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments; Longueur: 1000 mm; Matériau: JAUNE-2; Norme: NF EN 12 613; Plan de construction: Niveau : Niveau 1
Cotes - Longueur Panneau: 100 mm; Réseau LONG: 10; Surface: 0.09072 m2; Volume: 0.0000336 m3
Phase de construction - Phase de création: Nouvelle construction
